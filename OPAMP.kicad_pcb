# Repository llLeo306/MicroCoil_AFE

## KiCad design OPAMP.kicad_pcb

Parts:
C1, C14: 4.7nF; C_0603_1608Metric
C2, C3: 100pF; C_0603_1608Metric
C4, C6, C8, C10, C16: 100nF; C_0603_1608Metric
C5, C7, C9, C15: 10uF; C_0603_1608Metric
C11: 4.7uF; C_0603_1608Metric
C12: 47nF; C_0603_1608Metric
C13, C17, C18: 1uF; C_0603_1608Metric
D1, D2: PESD5V0X1BL-N; voltage 5 V; MPN PESD5V0X1BL-N
FB1: BLM18SP102SH1D; tolerance 25 %; MPN BLM18SP102SH1D
J1, J4: GH125-S02CCA-00; MPN GH125-S02CCA-00
J3: GH125-S03DCA-00; MPN GH125-S03DCA-00
R1, R2, R9: 49.9; C_0603_1608Metric
R3, R4, R17: 0; C_0603_1608Metric
R5, R10, R11, R12, R13: 100K; C_0603_1608Metric
R6: 49.9K; C_0603_1608Metric
R7: 5.49K; C_0603_1608Metric
R8: 499; C_0603_1608Metric
R14: 68K; C_0603_1608Metric
R15: 1K; C_0603_1608Metric
R16: 10K; C_0603_1608Metric
R18: 28.7K; C_0603_1608Metric
R19, R20: 100; C_0603_1608Metric
SW1: DSHP02TSGET; voltage_rating 24 V; MPN DSHP02TSGET
U1: ADG704BRMZ-REEL; voltage 1.8 V; MPN ADG704BRMZ-REEL
U2: AD8421BRZ-RL; voltage_gain 80 dB; MPN AD8421BRZ-RL
U3: OPA2197QDGKRQ1; MPN OPA2197QDGKRQ1
U4: REF2030AIDDCR; tolerance 0.05 %; voltage 3.02 V; MPN REF2030AIDDCR

Connections:
+5VA: C4.1, C5.1, C6.1, C7.1, C8.1, C13.1, FB1.2, R13.2, R16.1, SW1.1 (A1), SW1.2 (A2), U1.6 (VDD), U2.8 (+VS), U3.8 (V+), U4.4 (IN)
/+5VIN: C9.1, C10.1, FB1.1, J4.2
/AGND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, J3.3, J4.1, R5.2, R10.2, R17.2, U1.3 (GND), U2.5 (–VS), U3.4 (V-), U4.2 (GND)
/AGND_SHIELD: D1.2, D2.2, J1.3, J1.4, J3.4, J3.5, J4.3, J4.4, R17.1
/AIN_PRE: C11.1, U2.7 (VOUT)
/BIAS_1V5: J3.2, R11.2, R12.2, R14.2, R15.1, U2.6 (REF), U3.6 (-), U3.7
/BIAS_FILT: C15.1, C16.1, R20.2, U3.5 (+)
/BIAS_RAW: C18.1, R20.1, U4.1 (Vbias)
/COIL_FILT_N: C1.2, C3.1, R2.2, R12.1, U2.1 (–IN)
/COIL_FILT_P: C1.1, C2.1, R1.2, R11.1, U2.4 (+IN)
/COIL_RAW_N: D2.1, J1.1, R2.1
/COIL_RAW_P: D1.1, J1.2, R1.1
/HP_IN: C11.2, R14.1, U3.3 (+)
/RG_A: R6.1, R7.1, R8.1, R9.1, U2.2 (RG)
/RG_B: U1.8 (D), U2.3 (RG)
/VOUT: C14.1, J3.1, R19.2
/VOUT_RAW: C12.2, R15.2, R18.2, R19.1, U3.2 (-)
/VREF_3V0: C17.1, U4.5 (Vref)
unnamed: C12.1, R18.1, U3.1
unnamed: R4.1, SW1.4 (B1)
unnamed: R3.1, SW1.3 (B2)
unnamed: R3.2, R5.1, U1.1 (A0)
unnamed: R4.2, R10.1, U1.10 (A1)
unnamed: R13.1, U1.5 (EN)
unnamed: R6.2, U1.2 (S1)
unnamed: R7.2, U1.9 (S2)
unnamed: R8.2, U1.4 (S3)
unnamed: R9.2, U1.7 (S4)
unnamed: R16.2, U4.3 (EN)

Notes on the sheet:
1.5V偏置
二级放大
RG模拟开关
一级放大
电源入口滤波

Board: 2 copper layers, 46.0 x 17.0 mm, 49 parts (0 on the bottom side), 29 nets.

## Commit log

2026-02-28 第一次提交
2026-04-05 Layout
2026-04-05 更换蛇形走线
2026-04-05 更改铺铜有é有优先级å，添加泪滴
2026-04-06 remake
